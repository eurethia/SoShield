/**
   BasicHTTPClient.ino

    Created on: 24.05.2015

*/

#include <Arduino.h>

#include <ESP8266WiFi.h>
#include <ESP8266WiFiMulti.h>

#include <ESP8266HTTPClient.h>

#include <WiFiClient.h>
#include <Wire.h>

ESP8266WiFiMulti WiFiMulti;
static int flag =  0;

void setup() {

  Serial.begin(9600);
  Wire.begin(D1, D2); 
  Serial.println();
  Serial.println();
  Serial.println();

  for (uint8_t t = 4; t > 0; t--) {
    Serial.printf("[SETUP] WAIT %d...\n", t);
    Serial.flush();
    delay(1000);
  }

  WiFi.mode(WIFI_STA);
  WiFiMulti.addAP("hotspot", "1233211234567");

}

void loop() {
   Wire.beginTransmission(8); /* begin with device address 8 */
   Wire.write("Hello Arduino");  /* sends hello string */
   Wire.endTransmission();    /* stop transmitting */
   Wire.requestFrom(8, 1); /* request & read data of size 13 from slave */
   while(Wire.available()){
      char c = Wire.read();
      if(c=='Y'){
        flag = 1;
      }else{
        flag = 0 ;
      }
      Serial.print(c);
   }
   Serial.println();
   delay(1000);
  if(flag){
    if ((WiFiMulti.run() == WL_CONNECTED)) {

      WiFiClient client;
  
      HTTPClient http;
  
      Serial.print("[HTTP] begin...\n");
      if (http.begin(client, "http://172.20.10.3:5000/stop/")) {  // HTTPhttp://192.168.2.117:5000/stop/
  
  
        Serial.print("[HTTP] GET...\n");
        // start connection and send HTTP header
        int httpCode = http.GET();
  
        // httpCode will be negative on error
        if (httpCode > 0) {
          // HTTP header has been send and Server response header has been handled
          Serial.printf("[HTTP] GET... code: %d\n", httpCode);
  
          // file found at server
          if (httpCode == HTTP_CODE_OK || httpCode == HTTP_CODE_MOVED_PERMANENTLY) {
            String payload = http.getString();
            Serial.println(payload);
          }
        } else {
          Serial.printf("[HTTP] GET... failed, error: %s\n", http.errorToString(httpCode).c_str());
        }
  
        http.end();
      } else {
        Serial.printf("[HTTP} Unable to connect\n");
      }
    }
    delay(1000*10);
  }
  // wait for WiFi connection
  

}
